EXTRA_OECMAKE:append = " \
    -Dbios-post-code-log=enabled \
    -Dmax-post-code-size-per-cycle=100 \
"
