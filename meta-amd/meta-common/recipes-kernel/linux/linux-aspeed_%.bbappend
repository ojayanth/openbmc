LINUX_VERSION:amd ?= "6.6.22"
KSRC:amd ?= "git://github.com/AMDESE/linux-aspeed;protocol=https;branch=sp7-dev"
SRCREV="74d2878d4e2b5d97e5d2ac4ec30e19b5c926c297"
