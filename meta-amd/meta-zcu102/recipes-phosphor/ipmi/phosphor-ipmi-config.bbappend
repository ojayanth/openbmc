FILESEXTRAPATHS:prepend:zynq := "${THISDIR}/${PN}:"
