KBRANCH = "aspeed-master-v6.6"
LINUX_VERSION ?= "6.6.93"

# Tag for v00.06.07+
SRCREV = "546f2f80e3d44dfb2acf8404f41dffb483662628"

require linux-aspeed-sdk.inc
